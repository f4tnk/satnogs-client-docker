options:
  parameters:
    author: knegge
    generate_options: no_gui
    id: udp2ishort
    output_language: python
    run_options: run
    title: Read UDP from a SatNOGS flowgraph
  states: {}

blocks:
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/stdout
    type: short
    unbuffered: 'True'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '16768'
    type: complex
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    alias: blocks_udp_source_0
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: udp_dump_port
    src_zeros: 'False'
    type: complex
  states: {}
- name: udp_dump_host
  id: parameter
  parameters:
    label: host/ip to bind udp sink
    short_id: u
    type: str
    value: '"0.0.0.0"'
  states: {}
- name: udp_dump_port
  id: parameter
  parameters:
    label: host port for udp sink
    short_id: p
    type: intx
    value: '57356'
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [network_udp_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
